# IAR project GPIO_LED_Toggle.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MM32SPIN05PT MindMotion MM32SPIN05PT
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: _DLIB_FILE_DESCRIPTOR; USE_STDPERIPH_DRIVER; USE_IAR
  ICCARM.CCIncludePath2: ..; ..\..\..\..\..\Device\CMSIS\IAR_Core; ..\..\..\..\..\Device\MM32SPIN0x_q\HAL_Lib\Inc; ..\..\..\..\..\Device\MM32SPIN0x_q\Include; ..\..\..\..\..\ClassBTest\Library\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GPIO_LED_Toggle.hex
  postbuild: crc_gen_keil.bat
  ILINK.IlinkOutputFile: GPIO_LED_Toggle.out
  ILINK.IlinkIcfFile: ClassBTest.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  group APP
    ../: gpio_led_toggle.c main.c mm32spin05_it.c platform.c
  group ClassB
    ../../../../Library/src/: IEC60730_B_aux.c IEC60730_B_clocktest.c IEC60730_B_flashtest.c IEC60730_B_runtimetest.c IEC60730_B_startup.c IEC60730_B_transpRam.c
    ../../../../Library/: IEC60730B_M0_COM_IAR_v1_0.a
  group DOC
    ../: readme.txt
  group HAL_LIB
    ../../../../../Device/MM32SPIN0x_q/HAL_Lib/Src/: hal_adc.c hal_comp.c hal_crc.c hal_dbg.c hal_div.c hal_dma.c hal_exti.c hal_flash.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_misc.c hal_pwr.c hal_rcc.c hal_spi.c hal_tim.c hal_uart.c hal_uid.c hal_ver.c hal_wwdg.c
  group STARTUP
    ../../../../../Device/MM32SPIN0x_q/Source/IAR_StartAsm/: startup_mm32spin0x_q_iar.s
    ../../../../../Device/MM32SPIN0x_q/Source/: system_mm32spin0x_q.c
