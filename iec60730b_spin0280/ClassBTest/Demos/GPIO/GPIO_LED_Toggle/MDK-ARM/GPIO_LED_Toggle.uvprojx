# Keil uVision project GPIO_LED_Toggle.uvprojx, settings and files
target GPIO_LED_Toggle (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: MM32SPIN0280D7P MindMotion
  pack: MindMotion.MM32SPIN0280_DFP.0.0.1
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: GPIO_LED_Toggle +hex
  AfterMake: .\crc_gen_keil.bat
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=5 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\GPIO_LED_Toggle;..\..\..\..\..\Device\CMSIS\KEIL_Core;..\..\..\..\..\Device\MM32SPIN0280\HAL_Lib\Inc;..\..\..\..\..\Device\MM32SPIN0280\Include;..\..\..\..\..\ClassBTest\Library\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\ClassBtest.sct
  group APP
    ../: main.c gpio_led_toggle.c platform.c mm32spin0280_it.c
  group DOC
    ../: readme.txt
  group HAL_LIB
    ../../../../../Device/MM32SPIN0280/HAL_Lib/Src/: hal_adc.c hal_bkp.c hal_comp.c hal_crc.c hal_csm.c hal_dac.c hal_dbg.c hal_div.c hal_dma.c hal_exti.c hal_flash.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_misc.c hal_opamp.c hal_pwr.c hal_rcc.c hal_spi.c hal_sqrt.c hal_tim.c hal_uart.c hal_uid.c hal_ver.c hal_wwdg.c
  group STARTUP
    ./: startup_mm32spin0280_keil.s
    ../../../../../Device/MM32SPIN0280/Source/: system_mm32spin0280.c
  group ClassB
    ../../../../../ClassBTest/Library/src/: IEC60730_B_startup.c IEC60730_B_runtimetest.c IEC60730_B_clocktest.c IEC60730_B_aux.c
    ../../../../Library/src/: IEC60730_B_flashtest.c IEC60730_B_transpRam.c
    ../../../../Library/: IEC60730B_M0_COM_KEIL_v1_0.lib
