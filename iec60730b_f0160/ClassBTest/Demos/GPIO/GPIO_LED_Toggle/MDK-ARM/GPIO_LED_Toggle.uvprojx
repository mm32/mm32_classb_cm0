# Keil uVision project GPIO_LED_Toggle.uvprojx, settings and files
target GPIO_LED_Toggle (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MM32F0162D7PV MindMotion
  pack: MindMotion.MM32F0160_DFP.1.1.1
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: GPIO_LED_Toggle +hex
  AfterMake: .\crc_gen_keil.bat
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=5 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\GPIO_LED_Toggle;..\..\..\..\..\Device\CMSIS\KEIL_Core;..\..\..\..\..\Device\MM32F0160\HAL_Lib\Inc;..\..\..\..\..\Device\MM32F0160\Include;..\..\..\..\..\ClassBTest\Library\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\ClassBtest.sct
  group APP
    ../: main.c gpio_led_toggle.c platform.c mm32f0160_it.c
  group DOC
    ../: readme.txt
  group HAL_LIB
    ../../../../../Device/MM32F0160/HAL_lib/src/: hal_adc.c hal_bkp.c hal_comp.c hal_crc.c hal_crs.c hal_dbg.c hal_dma.c hal_exti.c hal_flash.c hal_flexcan.c hal_gpio.c hal_hwdiv.c hal_i2c.c hal_i3c.c hal_iwdg.c hal_lptim.c hal_lpuart.c hal_misc.c hal_pwr.c hal_rcc.c hal_rtc.c hal_spi.c hal_tim.c hal_uart.c hal_uid.c hal_usb.c hal_ver.c hal_wwdg.c
  group STARTUP
    ../../../../../Device/MM32F0160/Source/: system_mm32f0160.c
    ./: startup_mm32f0160_keil.s
  group ClassB
    ../../../../Library/src/: IEC60730_B_startup.c IEC60730_B_runtimetest.c IEC60730_B_clocktest.c IEC60730_B_aux.c IEC60730_B_flashtest.c IEC60730_B_transpRam.c
    ../../../../Library/: IEC60730B_M0_COM_KEIL_v1_0.lib
