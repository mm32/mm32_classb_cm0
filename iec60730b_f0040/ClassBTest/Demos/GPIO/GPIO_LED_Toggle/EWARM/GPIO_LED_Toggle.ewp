# IAR project GPIO_LED_Toggle.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MM32F0040B1T MindMotion MM32F0040B1T
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..; ..\..\..\..\..\Device\CMSIS\IAR_Core; ..\..\..\..\..\Device\MM32F0040\HAL_Lib\inc; ..\..\..\..\..\Device\MM32F0040\Include; ..\..\..\..\Library\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GPIO_LED_Toggle.hex
  postbuild: crc_gen_keil.bat
  ILINK.IlinkOutputFile: GPIO_LED_Toggle.out
  ILINK.IlinkIcfFile: ClassBTest.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APP
    ../: gpio_led_toggle.c main.c mm32f0040_it.c platform.c
  group ClassB
    ../../../../Library/src/: IEC60730_B_aux.c IEC60730_B_clocktest.c IEC60730_B_flashtest.c IEC60730_B_runtimetest.c IEC60730_B_startup.c IEC60730_B_transpRam.c
    ../../../../Library/: IEC60730B_M0_COM_IAR_v1_0.a
  group DOC
    ../: readme.txt
  group HAL_LIB
    ../../../../../Device/MM32F0040/HAL_Lib/Src/: hal_adc.c hal_comp.c hal_crc.c hal_dbg.c hal_div.c hal_dma.c hal_exti.c hal_flash.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_misc.c hal_pwr.c hal_rcc.c hal_spi.c hal_tim.c hal_uart.c hal_uid.c hal_ver.c hal_wwdg.c
  group STARTUP
    ./: startup_mm32f0040_iar.s
    ../../../../../Device/MM32F0040/Source/: system_mm32f0040.c
